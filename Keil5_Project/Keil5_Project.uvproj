# Keil uVision project Keil5_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Keil5_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Sources/: DS1302.c ds1302.h LCD1602.c LCD1602.h main.c
